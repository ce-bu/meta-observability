FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
EXTRA_OECONF_append = " --enable-frame-pointer"
