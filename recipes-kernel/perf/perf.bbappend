PACKAGECONFIG = "scripting tui libunwind dwarf cap systemtap"